# Keil uVision project lab1(method2).uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ATSAM3N4A Microchip
  pack: Atmel.SAM3N_DFP.1.0.62
  cpu: IRAM(0x20000000,0x00006000) IROM(0x00400000,0x00040000) IROM2(0x00800000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab1(method2)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT5: ROM 0x800000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./: lab1(method2).s
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
